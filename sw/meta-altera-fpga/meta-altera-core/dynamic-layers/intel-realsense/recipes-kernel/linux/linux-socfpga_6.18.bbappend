FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://realsense.cfg"
SRC_URI += "file://6.18-realsense-camera-formats.patch"

