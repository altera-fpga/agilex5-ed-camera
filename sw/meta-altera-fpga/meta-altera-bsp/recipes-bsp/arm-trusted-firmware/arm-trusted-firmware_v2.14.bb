require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6ed7bace7b0bc63021c6eba7b524039e"

ATF_VERSION = "v2.14.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "d1ca26265db2b4c3c4eb9c9bdb0d2547002058a6"
