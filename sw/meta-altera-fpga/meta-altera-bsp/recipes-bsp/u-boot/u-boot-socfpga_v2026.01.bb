require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2026.01"

SRCREV = "db060c90cff8ac655ae2d228b0107d22eafbee59"
