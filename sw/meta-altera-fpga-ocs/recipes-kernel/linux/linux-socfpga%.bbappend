FILESEXTRAPATHS:prepend := "${THISDIR}/config:"
SRC_URI:append = " file://config_uio.cfg"
