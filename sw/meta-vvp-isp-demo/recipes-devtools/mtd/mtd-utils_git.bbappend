SRC_URI = "git://git.infraroot.at/mtd-utils.git;branch=master;protocol=https"
